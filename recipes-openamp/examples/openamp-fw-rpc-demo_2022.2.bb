require openamp-fw.inc

YAML_BSP_CONFIG[WITH_PROXY] = "set,true"

XSCTH_APP = "OpenAMP RPC Demo"

OPENAMP_FW_NAME = "image_rpc_demo"
