require openamp-fw.inc

XSCTH_APP = "OpenAMP echo-test"

OPENAMP_FW_NAME = "image_echo_test"
