require openamp-fw.inc

XSCTH_APP = "OpenAMP matrix multiplication Demo"

OPENAMP_FW_NAME = "image_matrix_multiply"

