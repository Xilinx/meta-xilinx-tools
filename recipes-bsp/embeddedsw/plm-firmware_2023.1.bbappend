require ${@'plm-firmware_2023.1-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
