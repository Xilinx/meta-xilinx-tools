require ${@'imgsel-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
