require ${@'fsbl-firmware_2024.2-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
