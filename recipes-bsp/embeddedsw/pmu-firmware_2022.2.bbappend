require ${@'pmu-firmware_2022.2-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
