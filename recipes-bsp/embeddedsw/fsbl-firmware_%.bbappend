require ${@'fsbl-firmware_xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
