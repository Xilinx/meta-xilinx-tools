require ${@'pmu-firmware_2023.2-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
