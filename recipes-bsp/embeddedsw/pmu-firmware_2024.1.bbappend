require ${@'pmu-firmware_2024.1-xsct.inc' if d.getVar('XILINX_WITH_ESW') == 'xsct' else ''}
