# This lets plmfw be build completely within a Linux build
PLM_DEPENDS ?= "fsbl-firmware:do_deploy"
PLM_MCDEPENDS ?= ""
