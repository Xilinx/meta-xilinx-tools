inherit bootbin-component
BOOTBIN_BIF_FRAGMENT_zynqmp = "destination_cpu=a53-0, exception_level=el-3, trustzone"
