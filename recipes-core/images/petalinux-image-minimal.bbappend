require xsct-tarball-esdk.inc
