#
# Copyright (C) 2023, Advanced Micro Devices, Inc.  All rights reserved.
#
# SPDX-License-Identifier: MIT
#
# This bbclass is inherited by Versal Classic SoC Partial firmware app recipes.

YAML_ENABLE_CLASSIC_SOC = "1"
inherit dfx_dtg_partial_common
