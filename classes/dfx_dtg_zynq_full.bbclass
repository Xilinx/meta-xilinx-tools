inherit dfx_dtg_full_internal
