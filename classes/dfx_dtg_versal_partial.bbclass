inherit dfx_dtg_partial
