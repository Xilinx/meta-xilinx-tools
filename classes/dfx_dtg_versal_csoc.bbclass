YAML_ENABLE_CLASSIC_SOC = "1"
inherit dfx_dtg_partial
